

PACKAGE_INSTALL += " \
    initramfs-module-dmverity-sig \
    verify-sb\
"

